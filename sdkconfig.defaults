## sdkconfig.defaults.esp32p4
```kconfig
# Waveshare P4 flash defaults.
CONFIG_ESPTOOLPY_FLASHSIZE_32MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="32MB"
```
